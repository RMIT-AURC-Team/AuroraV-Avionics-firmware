# Keil uVision project AuroraV-Avionics.uvprojx, settings and files
target AuroraV-Avionics (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F439IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AuroraV-Avionics
  group Application/MDK-ARM
    ./: startup_stm32f4xx.s
  group Source
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c boardSupport.c gpioControl.c highrestask.c lowrestask.c stateupdatetask.c memflashtask.c iomontask.c init.c baro.c accelX.c gyroX.c gyroY.c gyroZ.c buffer.c
    ../../AuroraV-Avionics-lib/bin/: libavionics.a
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Headers
    ../Core/Inc/: boardSupport.h FreeRTOSConfig.h gpioControl.h main.h stm32f4xx_it.h ioMapping.h tasks.h init.h buffer.h
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: portmacro.h
software components: CMSIS:CORE 6.1.0
